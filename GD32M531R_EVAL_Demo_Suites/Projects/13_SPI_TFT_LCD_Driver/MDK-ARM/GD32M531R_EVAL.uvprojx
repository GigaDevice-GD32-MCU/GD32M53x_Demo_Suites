# Keil uVision project GD32M531R_EVAL.uvprojx, settings and files
target GD32M53x (6130001::V6.13.1::.\ARMCLANG)
  device: GD32M531RC GigaDevice
  pack: GigaDevice.GD32M53x_DFP.0.1.9
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x040000) IROM2(0x08800000,0x010000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32M53X,USE_STDPERIPH_DRIVER,FW_DEBUG_ERR_REPORT
  c misc: -Wassign-enum
  c include: ..\;..\..\..\..\GD32M53x_Firmware_Library\CMSIS;..\..\..\..\GD32M53x_Firmware_Library\CMSIS\GD\GD32M53x\Include;..\..\..\..\GD32M53x_Firmware_Library\GD32M53x_standard_peripheral\Include;..\..\..\Utilities;..\Soft_Drive
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT5: ROM 0x8800000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../: main.c systick.c gd32m53x_it.c
  group CMSIS
    ../../../../GD32M53x_Firmware_Library/CMSIS/GD/GD32M53x/Source/: system_gd32m53x.c gd32m53x_err_report.c
  group GD32M53x_Peripherals
    ../../../../GD32M53x_Firmware_Library/GD32M53x_standard_peripheral/Source/: gd32m53x_adc.c gd32m53x_can.c gd32m53x_crc.c gd32m53x_cfmu.c gd32m53x_dac.c gd32m53x_dbg.c gd32m53x_dma.c gd32m53x_exti.c gd32m53x_fmc.c gd32m53x_gpio.c gd32m53x_i2c.c gd32m53x_misc.c gd32m53x_pmu.c gd32m53x_rcu.c gd32m53x_spi.c gd32m53x_timer.c gd32m53x_tmu.c gd32m53x_syscfg.c gd32m53x_fwdgt.c gd32m53x_wwdgt.c gd32m53x_cmp.c gd32m53x_evic.c gd32m53x_gptimer.c gd32m53x_gtoc.c gd32m53x_poc.c gd32m53x_svpwm.c gd32m53x_uart.c gd32m53x_cptimer.c gd32m53x_cptimerw.c
  group GD32M53x_EVAL
    ../../../Utilities/: gd32m53x_eval.c
  group Soft_Drive
    ../Soft_Drive/: gui.c lcd_driver.c tft_test.c
  group Startup
    ../../../../GD32M53x_Firmware_Library/CMSIS/GD/GD32M53x/Source/ARM/: startup_gd32m53x.s
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.6.0
