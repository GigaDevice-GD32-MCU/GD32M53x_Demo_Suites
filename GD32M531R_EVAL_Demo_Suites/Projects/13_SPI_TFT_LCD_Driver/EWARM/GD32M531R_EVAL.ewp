# IAR project GD32M531R_EVAL.ewp, settings and files
configuration GD32M53x (ARM, debug)
  General.OGChipSelectEditMenu: GD32M531xC GD GD32M531xC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: GD32M53X; USE_STDPERIPH_DRIVER; FW_DEBUG_ERR_REPORT
  ICCARM.CCIncludePath2: ../; ../../../../GD32M53x_Firmware_Library/CMSIS; ../../../../GD32M53x_Firmware_Library/CMSIS/GD/GD32M53x/Include; ../../../../GD32M53x_Firmware_Library/GD32M53x_standard_peripheral/Include; ../../../Utilities; ../Soft_Drive
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: template_project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../: gd32m53x_it.c main.c systick.c
  group CMSIS
    ../../../../GD32M53x_Firmware_Library/CMSIS/GD/GD32M53x/Source/: gd32m53x_err_report.c system_gd32m53x.c
  group Doc
    ../: readme.txt
  group GD32M53x_EVAL
    ../../../Utilities/: gd32m53x_eval.c
  group GD32M53x_Peripherals
    ../../../../GD32M53x_Firmware_Library/GD32M53x_standard_peripheral/Source/: gd32m53x_adc.c gd32m53x_can.c gd32m53x_cfmu.c gd32m53x_cmp.c gd32m53x_cptimer.c gd32m53x_cptimerw.c gd32m53x_crc.c gd32m53x_dac.c gd32m53x_dbg.c gd32m53x_dma.c gd32m53x_evic.c gd32m53x_exti.c gd32m53x_fmc.c gd32m53x_fwdgt.c gd32m53x_gpio.c gd32m53x_gptimer.c gd32m53x_gtoc.c gd32m53x_i2c.c gd32m53x_misc.c gd32m53x_pmu.c gd32m53x_poc.c gd32m53x_rcu.c gd32m53x_spi.c gd32m53x_svpwm.c gd32m53x_syscfg.c gd32m53x_timer.c gd32m53x_tmu.c gd32m53x_uart.c gd32m53x_wwdgt.c
  group Soft_Drive
    ../Soft_Drive/: gui.c lcd_driver.c tft_test.c
  group Startup
    ../../../../GD32M53x_Firmware_Library/CMSIS/GD/GD32M53x/Source/IAR/: startup_gd32m53x.s
