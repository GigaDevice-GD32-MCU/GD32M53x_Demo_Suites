<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\GD32M531R_EVAL.ewp</path>
  </project>
  <batchBuild/>
</workspace>
